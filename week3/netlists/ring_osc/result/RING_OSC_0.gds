# Layout, gdstk code
from math import pi, radians
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
nwell = (64, 20)
diff = (65, 20)
tap = (65, 44)
poly = (66, 20)
licon = (66, 44)
li1 = (67, 20)
mcon = (67, 44)
met1 = (68, 20)
via = (68, 44)
met2 = (69, 20)
nsdm = (93, 44)
psdm = (94, 20)
L100_5 = (100, 5)
L235_5 = (235, 5)

nmos_s_81537667_x1_y1_16 = lib.new_cell('NMOS_S_81537667_X1_Y1_1677543507_1677543509')
R(nmos_s_81537667_x1_y1_16, diff, [(0.735,2.625,1.845,3.045)])
R(nmos_s_81537667_x1_y1_16, tap, [(1.205,6.16,1.375,7.28)])
R(nmos_s_81537667_x1_y1_16, poly, [(1,1.26,1.15,4.62), (1.43,1.26,1.58,4.62), (1,4.485,1.58,4.755)])
A(nmos_s_81537667_x1_y1_16, licon, 0.775, 2.705, 0.17, 0.17, 3, 1, 0.43, 0)
R(nmos_s_81537667_x1_y1_16, licon, [(1.205,4.535,1.375,4.705), (1.205,6.635,1.375,6.805)])
A(nmos_s_81537667_x1_y1_16, li1, 0.735, 0.335, 0.25, 3.53, 3, 1, 0.43, 0)
R(nmos_s_81537667_x1_y1_16, li1, [(1.165,4.115,1.415,5.125), (1.165,6.215,1.415,7.225)])
R(nmos_s_81537667_x1_y1_16, mcon, [(1.205,0.335,1.375,0.505), (0.775,0.755,0.945,0.925), (1.635,0.755,1.805,0.925), (1.205,4.535,1.375,4.705), (1.205,6.635,1.375,6.805)])
R(nmos_s_81537667_x1_y1_16, met1, [(0.26,0.28,1.46,0.56), (0.69,0.7,1.89,0.98), (0.26,4.48,1.46,4.76), (0.69,6.58,1.89,6.86)])
R(nmos_s_81537667_x1_y1_16, via, [(1.645,0.765,1.795,0.915), (1.645,6.645,1.795,6.795)])
R(nmos_s_81537667_x1_y1_16, met2, [(1.58,0.68,1.86,6.88)])
R(nmos_s_81537667_x1_y1_16, nsdm, [(0,0,2.58,5.88)])
R(nmos_s_81537667_x1_y1_16, psdm, [(0,5.88,2.58,7.56)])
R(nmos_s_81537667_x1_y1_16, L100_5, [(0,0,2.58,7.56)])

pmos_s_19302086_x1_y1_16 = lib.new_cell('PMOS_S_19302086_X1_Y1_1677543508_1677543509')
R(pmos_s_19302086_x1_y1_16, nwell, [(0,0,2.58,7.56)])
R(pmos_s_19302086_x1_y1_16, diff, [(0.735,2.625,1.845,3.045)])
R(pmos_s_19302086_x1_y1_16, tap, [(1.205,6.16,1.375,7.28)])
R(pmos_s_19302086_x1_y1_16, poly, [(1,1.26,1.15,4.62), (1.43,1.26,1.58,4.62), (1,4.485,1.58,4.755)])
A(pmos_s_19302086_x1_y1_16, licon, 0.775, 2.705, 0.17, 0.17, 3, 1, 0.43, 0)
R(pmos_s_19302086_x1_y1_16, licon, [(1.205,4.535,1.375,4.705), (1.205,6.635,1.375,6.805)])
A(pmos_s_19302086_x1_y1_16, li1, 0.735, 0.335, 0.25, 3.53, 3, 1, 0.43, 0)
R(pmos_s_19302086_x1_y1_16, li1, [(1.165,4.115,1.415,5.125), (1.165,6.215,1.415,7.225)])
R(pmos_s_19302086_x1_y1_16, mcon, [(1.205,0.335,1.375,0.505), (0.775,0.755,0.945,0.925), (1.635,0.755,1.805,0.925), (1.205,4.535,1.375,4.705), (1.205,6.635,1.375,6.805)])
R(pmos_s_19302086_x1_y1_16, met1, [(0.26,0.28,1.46,0.56), (0.69,0.7,1.89,0.98), (0.26,4.48,1.46,4.76), (0.69,6.58,1.89,6.86)])
R(pmos_s_19302086_x1_y1_16, via, [(1.645,0.765,1.795,0.915), (1.645,6.645,1.795,6.795)])
R(pmos_s_19302086_x1_y1_16, met2, [(1.58,0.68,1.86,6.88)])
R(pmos_s_19302086_x1_y1_16, nsdm, [(0,5.88,2.58,7.56)])
R(pmos_s_19302086_x1_y1_16, psdm, [(0,0,2.58,5.88)])
R(pmos_s_19302086_x1_y1_16, L100_5, [(0,0,2.58,7.56)])

stage2_inv_5734008_0_0_1 = lib.new_cell('STAGE2_INV_5734008_0_0_1677543509')
R(stage2_inv_5734008_0_0_1, li1, [(2.885,2.855,3.135,3.025), (2.885,2.855,3.135,3.025), (2.885,2.855,3.135,3.025), (2.885,2.855,3.135,3.025), (2.885,2.855,3.135,3.025), (2.885,2.855,3.135,3.025), (2.885,2.94,3.135,7.14), (0.305,7.055,0.555,7.225), (0.305,7.055,0.555,7.225), (2.885,7.055,3.135,7.225), (2.885,7.055,3.135,7.225), (2.885,7.055,3.135,7.225), (2.885,7.055,3.135,7.225), (2.885,7.055,3.135,7.225), (2.885,7.055,3.135,7.225), (4.605,7.055,4.855,7.225), (4.605,7.055,4.855,7.225), (4.605,7.055,4.855,7.225), (4.605,7.055,4.855,7.225), (0.305,7.14,0.555,7.98), (2.885,7.14,3.135,12.18), (4.605,7.14,4.855,7.98), (0.305,7.895,0.555,8.065), (0.305,7.895,0.555,8.065), (4.605,7.895,4.855,8.065), (4.605,7.895,4.855,8.065), (4.605,7.895,4.855,8.065), (4.605,7.895,4.855,8.065), (2.885,12.095,3.135,12.265), (2.885,12.095,3.135,12.265)])
R(stage2_inv_5734008_0_0_1, mcon, [(2.925,2.855,3.095,3.025), (2.925,2.855,3.095,3.025), (2.925,2.855,3.095,3.025), (2.925,2.855,3.095,3.025), (2.925,2.855,3.095,3.025), (2.925,2.855,3.095,3.025), (0.345,7.055,0.515,7.225), (0.345,7.055,0.515,7.225), (2.925,7.055,3.095,7.225), (2.925,7.055,3.095,7.225), (2.925,7.055,3.095,7.225), (2.925,7.055,3.095,7.225), (2.925,7.055,3.095,7.225), (2.925,7.055,3.095,7.225), (4.645,7.055,4.815,7.225), (4.645,7.055,4.815,7.225), (4.645,7.055,4.815,7.225), (4.645,7.055,4.815,7.225), (0.345,7.895,0.515,8.065), (0.345,7.895,0.515,8.065), (4.645,7.895,4.815,8.065), (4.645,7.895,4.815,8.065), (4.645,7.895,4.815,8.065), (4.645,7.895,4.815,8.065), (2.925,12.095,3.095,12.265), (2.925,12.095,3.095,12.265)])
R(stage2_inv_5734008_0_0_1, met1, [(1.56,1.12,1.88,1.4), (1.56,1.12,1.88,1.4), (1.72,1.12,3.44,1.4), (3.28,1.12,3.6,1.4), (3.28,1.12,3.6,1.4), (1.29,2.8,3.01,3.08), (2.84,2.8,3.18,3.08), (2.84,2.8,3.18,3.08), (2.84,2.8,3.18,3.08), (2.84,2.8,3.18,3.08), (2.84,2.8,3.18,3.08), (2.84,2.8,3.18,3.08), (3.71,2.8,4.03,3.08), (3.71,2.8,4.03,3.08), (0.26,7,0.6,7.28), (0.26,7,0.6,7.28), (2.84,7,3.18,7.28), (2.84,7,3.18,7.28), (2.84,7,3.18,7.28), (2.84,7,3.18,7.28), (2.84,7,3.18,7.28), (2.84,7,3.18,7.28), (3.01,7,3.87,7.28), (4.56,7,4.9,7.28), (4.56,7,4.9,7.28), (4.56,7,4.9,7.28), (4.56,7,4.9,7.28), (0.26,7.84,0.6,8.12), (0.26,7.84,0.6,8.12), (4.56,7.84,4.9,8.12), (4.56,7.84,4.9,8.12), (4.56,7.84,4.9,8.12), (4.56,7.84,4.9,8.12), (1.56,8.68,1.88,8.96), (1.56,8.68,1.88,8.96), (1.72,8.68,3.44,8.96), (3.28,8.68,3.6,8.96), (3.28,8.68,3.6,8.96), (1.29,12.04,3.01,12.32), (2.84,12.04,3.18,12.32), (2.84,12.04,3.18,12.32), (3.71,12.04,4.03,12.32), (3.71,12.04,4.03,12.32)])
P(stage2_inv_5734008_0_0_1, met1, [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)])
R(stage2_inv_5734008_0_0_1, via, [(1.645,1.185,1.795,1.335), (1.645,1.185,1.795,1.335), (3.365,1.185,3.515,1.335), (3.365,1.185,3.515,1.335), (3.795,2.865,3.945,3.015), (3.795,2.865,3.945,3.015), (1.645,8.745,1.795,8.895), (1.645,8.745,1.795,8.895), (3.365,8.745,3.515,8.895), (3.365,8.745,3.515,8.895), (3.795,12.105,3.945,12.255), (3.795,12.105,3.945,12.255)])
R(stage2_inv_5734008_0_0_1, met2, [(1.58,1.1,1.86,1.42), (1.58,1.1,1.86,1.42), (3.3,1.1,3.58,1.42), (3.3,1.1,3.58,1.42), (3.73,2.78,4.01,3.1), (3.73,2.78,4.01,3.1), (3.73,2.94,4.01,12.18), (1.58,8.66,1.86,8.98), (1.58,8.66,1.86,8.98), (3.3,8.66,3.58,8.98), (3.3,8.66,3.58,8.98), (3.73,12.02,4.01,12.34), (3.73,12.02,4.01,12.34)])
P(stage2_inv_5734008_0_0_1, met2, [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)])
R(stage2_inv_5734008_0_0_1, L235_5, [(0,0,5.16,15.12)])
stage2_inv_5734008_0_0_1.add(gdstk.Reference(nmos_s_81537667_x1_y1_16, (5.16,7.56), rotation=pi))
stage2_inv_5734008_0_0_1.add(gdstk.Reference(nmos_s_81537667_x1_y1_16, (0,7.56), x_reflection=True))
stage2_inv_5734008_0_0_1.add(gdstk.Reference(pmos_s_19302086_x1_y1_16, (5.16,7.56), rotation=pi, x_reflection=True))
stage2_inv_5734008_0_0_1.add(gdstk.Reference(pmos_s_19302086_x1_y1_16, (0,7.56)))

lib.write_gds('STAGE2_INV_5734008_0_0_1677543509.gds')
